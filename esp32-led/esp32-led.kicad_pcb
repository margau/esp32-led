# Repository margau/esp32-led

## KiCad design esp32-led/esp32-led.kicad_pcb

Parts:
C1, C2: 100u; C_Elec_6.3x7.7
C3: 10u; C_Elec_5x5.4
C4, C5, C6, C7: 100n; C_1206_3216Metric
C8: 470u; C_Elec_10x10.2
D1, D2: LED; LED_1206_3216Metric
D3: BAT60A; D_SOD-323
J1: Screw_Terminal_01x06; TerminalBlock_bornier-6_P5.08mm
J2: USB_B_Micro; USB_Micro-B_Wuerth_614105150721_Vertical_CircularHoles
J3: Screw_Terminal_01x02; TerminalBlock_bornier-2_P5.08mm
Q1, Q2: S8050; SOT-23
Q3: Q_PMOS_GSD; SOT-23
R1, R2, R7, R8: 10k; R_1206_3216Metric
R3, R4: 0R; R_1206_3216Metric
R5, R6: R; R_1206_3216Metric
R9: 100k; R_1206_3216Metric
R10: 470k; R_1206_3216Metric
R11, R12: 1k; R_1206_3216Metric
SW1: BOOT; SW_Push_1P1T_NO_6x6mm_H9.5mm
SW2: RST; SW_Push_1P1T_NO_6x6mm_H9.5mm
U1: ESP32-WROOM-32
U2: AZ1117-3.3; TO-252-2
U3: CH340C; SOIC-16_3.9x9.9mm_P1.27mm

Connections:
+3V3: C2.1, C3.1, C4.1, C5.1, R5.1, R7.1, R8.1, U1.2 (VDD), U2.2 (VO)
+5V: C1.1, C6.1, C8.1, D3.1 (K), J1.1, J1.6, Q3.2 (S), R10.1, U2.3 (VI), U3.16 (VCC)
BOOT: R3.1, R7.2, SW1.1 (A), U1.25 (IO0); also elsewhere on the board
DTR: Q1.1 (E), R2.2, U3.13 (~DTR)
EN: R4.1, R8.2, SW2.1 (A), U1.3 (EN); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, D1.1 (K), D2.1 (K), J1.3, J1.4, J2.5, J2.6, J3.2, R9.2, R10.2, SW1.2 (B), SW2.2 (B), U1.1 (GND), U1.15 (GND), U1.38 (GND), U1.39 (GND), U2.1 (GND), U3.1 (GND); also elsewhere on the board
IO2: R6.1, U1.24 (IO2)
LED1: J1.2, U1.14 (IO12)
LED2: J1.5, U1.13 (IO14)
unnamed: C7.1, U3.4 (V3)
unnamed: D1.2 (A), R5.2
unnamed: D2.2 (A), R6.2
unnamed: D3.2 (A), J2.1
unnamed: J2.2, U3.6 (UD-)
unnamed: J2.3, U3.5 (UD+)
unnamed: Q1.2 (B), R1.1
unnamed: Q1.3 (C), R3.2
unnamed: Q2.2 (B), R2.1
unnamed: Q2.3 (C), R4.2
unnamed: Q3.1 (G), R9.1
unnamed: R11.2, U3.2 (TXD)
unnamed: R12.1, U3.3 (RXD)
RTS: Q2.1 (E), R1.2, U3.14 (~RTS)
RXD0: R11.1, U1.34 (RXD0/IO3)
TXD0: R12.2, U1.35 (TXD0/IO1)
VBUS: J3.1, Q3.3 (D)

Board: 2 copper layers, 80.0 x 50.0 mm, 34 parts (0 on the bottom side), 26 nets.

Other parts of the board:
PRG: BOOT; SW_Push_1P1T_NO_6x6mm_H9.5mm
RESET: RST; SW_Push_1P1T_NO_6x6mm_H9.5mm

Their connections:
BOOT: PRG.1; also elsewhere on the board
EN: RESET.1; also elsewhere on the board
GND: PRG.2, RESET.2; also elsewhere on the board

## Commit log

2020-11-23 Fix Keep out Area layer
